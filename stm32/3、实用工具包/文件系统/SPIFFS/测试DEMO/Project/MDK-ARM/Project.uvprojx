# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --gnu
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Src;..\Src\letter-shell;..\Src\wiznet\inc;..\Src\wiznet\ioLibrary\Ethernet;..\Src\wiznet\ioLibrary\Internet;..\Src\wiznet\ioLibrary\Ethernet\W5500;..\Src\wiznet\ioLibrary\Internet\DNS;..\Src\mqtt\MQTT_API;..\Src\mqtt\MQTTPacket\src;..\Src\sfud\inc;..\Src\ff13c\source;..\Src\ntp;..\Src\littlefs;..\Src\littlefs\app;..\Src\spiffs\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: bsp_uart.c libc_assert.c libc_math.c libc_printf.c libc_string.c loopback.c main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c bsp_sim7600CE.c
    ../Src/letter-shell/: shell.c shell_ext.c shell_port.c
    ../Src/mqtt/MQTT_API/: mqtt_api.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_usart.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_ll_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Wiznet
    ../Src/wiznet/ioLibrary/Ethernet/: wizchip_conf.c wizchip_socket.c
    ../Src/wiznet/ioLibrary/Ethernet/W5500/: w5500.c
    ../Src/wiznet/ioLibrary/Internet/DHCP/: wizchip_dhcp.c
    ../Src/wiznet/ioLibrary/Internet/DNS/: wizchip_dns.c
    ../Src/: eth_config.c
  group phco_mqtt
    ../Src/mqtt/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../Src/mqtt/MQTT_API/: mqtt_interface.c MQTTClient.c
  group SFUD
    ../Src/sfud/src/: sfud.c sfud_sfdp.c
    ../Src/sfud/port/: sfud_port.c
  group FATFS
    ../Src/ff13c/source/: ff.c ffunicode.c diskio.c ffsystem.c
  group NTP
    ../Src/ntp/: ntp.c
  group littleFS
    ../Src/littlefs/: lfs.c lfs_util.c
    ../Src/littlefs/app/: app_lfs.c
  group Spiffs
    ../Src/spiffs/src/: spiffs_cache.c spiffs_check.c spiffs_gc.c spiffs_hydrogen.c spiffs_nucleus.c spiffs_app.c
software components: CMSIS:CORE 5.1.2, Compiler:I/O:STDERR 1.2.0
